# IAR project GSM_RTSO_FATFS.ewp, settings and files
configuration GSM_RTSO_FATFS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F407xx; STM32F40XX
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\Drivers\STM32F4xx_StdPeriph_Driver\inc; ..\Inc; ..\usb_cdc_device
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: GSM_RTSO_FATFS.srec
  ILINK.IlinkOutputFile: GSM_RTSO_FATFS.out
  ILINK.IlinkIcfFile: GSM_RTSO_FATFS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group Application/USB_CDC
    ../usb_cdc_device/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group Application/User
    ../Src/: freertos.c gpio.c main.c stm32f4xx_it.c tim.c tm_stm32f4_usb_vcp.c
    ../GSM/: hardwareProfile.h
  group Application/User/GSM
    ../GSM/: 1Wire.c 1Wire.h Arch.c Arch.h ComPort.c ComPort.h GenericTypeDefs.h gsm.c gsm.h programming.c programming.h SMS.c SMS.h TcpIp.c TcpIp.h tick.h TQueue.c TQueue.h VoiceCall.c VoiceCall.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
